options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: nfft
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '700000'
    low_cutoff_freq: '600000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '700000'
    low_cutoff_freq: '600000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: nfft
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: extras_impulse_1
  id: extras_impulse
  parameters:
    nend: '10'
    nfft: '1024'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '300000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: nfft
    name: '"No filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: nfft
    name: '"With Filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: nfft
    srate: samp_rate
    type: complex
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1_1_0, '0']
- [band_reject_filter_0, '0', qtgui_freq_sink_x_1_1_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_freq_sink_x_1_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', band_pass_filter_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', band_reject_filter_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', high_pass_filter_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', low_pass_filter_0, '0']
- [extras_impulse_1, '0', blocks_throttle_0_0_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_1_1_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_1_0, '0']

metadata:
  file_format: 1
