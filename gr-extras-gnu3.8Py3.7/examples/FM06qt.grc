options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: center_frequency
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 101.5e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: station_frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88e6
    step: '100000'
    stop: 108e6
    value: center_frequency
  states: {}
- name: xlate_filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 125000, 25000, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/dir/Desktop/test/testfile.ts
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.00001'
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '5000'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: extras_s_tcp_0
  id: extras_s_tcp
  parameters:
    address: 192.168.0.2
    port: '5000'
  states: {state: disabled}
- name: extras_s_udp_0
  id: extras_s_udp
  parameters:
    port: '5000'
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 8e6
    channel_mode: '0'
    gain_dB_ch0: '40'
    oversample: '0'
    rf_freq: center_frequency
    samp_rate: samp_rate
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX
    args: sdrplay=0
    bb_gain0: '20'
    bw0: 6e6
    freq0: center_frequency
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    int_max: '20'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: xlating_fir_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: station_frequency-center_frequency
    decim: int(samp_rate/channel_width)
    samp_rate: samp_rate
    taps: xlate_filter_taps
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', xlating_fir_filter, '0']
- [blocks_udp_source_0, '0', blocks_file_sink_0, '0']
- [blocks_udp_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [extras_s_tcp_0, '0', blocks_file_sink_0, '0']
- [extras_s_tcp_0, '0', blocks_multiply_const_vxx_1, '0']
- [extras_s_udp_0, '0', blocks_file_sink_0, '0']
- [extras_s_udp_0, '0', blocks_multiply_const_vxx_1, '0']
- [limesdr_source_0, '0', blocks_file_sink_0, '0']
- [limesdr_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', xlating_fir_filter, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [xlating_fir_filter, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
