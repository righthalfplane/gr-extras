options:
  parameters:
    category: Custom
    description: https://apollo.open-resource.org/mission:log:2012:05:06:rtlsdr-osmosdr-gnuradio-fm-receiver
    generate_options: qt_gui
    id: osmo_nfm_rx
    output_language: python
    run_options: run
    title: OSMOSDR NFM RX
  states: {}

blocks:
- name: RF_Gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '497000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '569000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '629000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '503000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '183000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '605000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '491000000'
  states: {}
- name: gain_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '200'
    value: '40'
  states: {}
- name: s_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    begin_tag: '0'
    file: /Users/dir/Desktop/atsc-tv/sndtestOK.wav
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.001'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: s_rate
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '1234'
    psize: '256'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '3700'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'False'
    type: cc
  states: {state: disabled}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: s_rate
    sps: '1.1'
  states: {}
- name: extras_s_tcp_0
  id: extras_s_tcp
  parameters:
    address: 192.168.0.2
    port: '5000'
  states: {state: disabled}
- name: extras_t_upd_0
  id: extras_t_upd
  parameters:
    addressi: 192.168.0.2
    porti: '1234'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 8e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 8e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    oversample: '4'
    rf_freq: freq
    samp_rate: s_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: s_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: s_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    ant0: ANTENNA A
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: sdrplay
    overall_gain0: '10'
    samp_rate: s_rate
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'False'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    type: fc32
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_file_source_0_0_0, '0', dc_blocker_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', dtv_atsc_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', dtv_atsc_rx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_udp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [dtv_atsc_rx_0, '0', blocks_char_to_float_0, '0']
- [dtv_atsc_rx_0, '0', blocks_udp_sink_0, '0']
- [dtv_atsc_rx_0, '0', extras_t_upd_0, '0']
- [extras_s_tcp_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [limesdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
